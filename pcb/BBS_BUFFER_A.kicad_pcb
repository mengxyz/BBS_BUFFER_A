# Repository mengxyz/BBS_BUFFER_A

File README.md:

# BBS_BUFFER_A
### BAMBU Filament Buffer alternative with super cheap component
Minimal, fast, and hardware‑focused firmware for the CH32V003.  
This project currently ships a clean **ADC → PWM** control loop with **button‑driven calibration** stored in flash.

Built with GPT Codex 5.2.

Based on the original BBS Buffer A project: `https://github.com/4061N/BBS-Buffer-A`

## Highlights
- 10‑bit ADC read on PA2, mapped to PWM duty.
- PWM output on PC4 (TIM1 CH4) by default.
- Short/long press calibration on PC1:
  - Short press → save **min ADC**
  - Long press → save **max ADC**
- Calibration stored in on‑chip flash (EEPROM‑style).
- UART debug prints on PD5 (115200 8N1).

## Quick Start (PlatformIO)
From repo root:
```bash
pio run -e genericCH32V003A4M6
pio run -t upload -e genericCH32V003A4M6
```

## Pin Map (current firmware)
- **PA2**: ADC input
- **PC4**: PWM output (TIM1 CH4)
- **PC1**: Button input (internal pull‑up, active‑low)
- **PD5**: UART TX (115200 8N1)
- **PC2**: WS2812 data (optional, not used by default)

## Calibration Behavior
On **button release**:
- Press < `BUTTON_LONG_MS` → save min ADC
- Press ≥ `BUTTON_LONG_MS` → save max ADC

Saved values are written to the **last flash page** and loaded on boot.  
If flash data is invalid, firmware falls back to defaults.

## Key Config Macros (src/main.c)
- `USE_CALC` — enable/disable flash calibration
- `UART_ENABLE` — UART debug prints
- `PWM_USE_PC4` — choose PWM pin (PC4 vs PA1)
- `ADC_MIN_DEFAULT`, `ADC_MAX_DEFAULT` — fallback range
- `BUTTON_LONG_MS` — long‑press threshold

## Files of Interest
- `src/main.c` — main control loop
- `src/calibration.c` / `include/calibration.h` — flash storage helpers

## Notes
Flash writes erase a full page. Avoid saving excessively in tight loops.

## Recommended 3D Model
[BBS Buffer A XMCU Series Buffer 3D model](https://makerworld.com/en/models/2035894-bbs-buffer-a-xmcu-series-buffer#profileId-2196013)

## KiCad design pcb/BBS_BUFFER_A.kicad_pcb

Parts:
C1, C3, C4: 10uF; C_1206_3216Metric; Manufacturer Part CL31A106KBHNNNE; LCSC Part Name 10uF ±10% 50V
C2, C5, C6, C7, C8: 100nF; C_0603_1608Metric; Tolerance ±10%; Voltage Rated 50V; Manufacturer Part CC0603KRX7R9BB104; LCSC Part Name 100nF ±10% 50V
CN1: HC-MX3.0-2*2AW; CONN-TH_4P-P3.00_HC-MX3.0-2X2AW_1; Manufacturer Part HC-MX3.0-2*2AW; LCSC Part Name 2x2P 间距:3mm 弯插 系列:Micro-Fit(MX 3.0)
CN2: HC-MX3.0-2*3AW; CONN-TH_6P-P3.00_HC-MX3.0-2X3AW_1; Manufacturer Part HC-MX3.0-2*3AW; LCSC Part Name 2x3P 间距:3mm 弯插 系列:Micro-Fit(MX 3.0)
D1: PSM712-LF-T7; SOT-23-3_L3.0-W1.7-P0.95-LS2.9-BR; Manufacturer Part PSM712-LF-T7; LCSC Part Name PSM712-LF-T7
J1, J2: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J3: GND; PinHeader_1x01_P2.54mm_Vertical
JP1: BUFF_SEL; SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm
JP2: RGB; R_0402_1005Metric
LED1: XL-5050RGBC-WS2812B; LED-SMD_4P-L5.0-W5.0-BL_XL-5050RGBC; Manufacturer Part XL-5050RGBC-WS2812B; LCSC Part Name XL-5050RGBC-WS2812B
R1: 10Ω; C_0603_1608Metric; Manufacturer Part 0603WAF100JT5E; LCSC Part Name 10Ω ±1% 100mW 厚膜电阻
R2: 120Ω; R_0603_1608Metric; Manufacturer Part 0603WAF1200T5E; LCSC Part Name 120Ω ±1% 100mW 厚膜电阻
R3, R4: 100kΩ; R_0603_1608Metric; Manufacturer Part 0603WAF1003T5E; LCSC Part Name 100kΩ ±1% 100mW 厚膜电阻
R5, R6, R7, R8: R_0402_1005Metric
SW1: B3U-1000P; SW-SMD_L4.0-W3.0-LS5.0; Manufacturer Part B3U-1000P; LCSC Part Name B3U-1000P
TP1, TP2, TP3: MountingHole_2.2mm_M2_DIN965
U1: MST5333BTS; SOT-89-3_L4.5-W2.5-P1.50-LS4.2-BR; LCSC Part C324582
U2: CH32V003JxMx; JEITA_SOIC-8_3.9x4.9mm_P1.27mm
U3: MAX3485EESA; SOIC-8_L4.9-W3.9-P1.27-LS6.0-BL; LCSC Part C9943
U4: OH49E-S; SOT-23-3_L2.9-W1.6-P1.90-LS2.8-BR; Manufacturer Part OH49E-S; LCSC Part Name 线性霍尔开关电路

Connections:
3.3V: C4.2, C6.2, C7.2, C8.2, J1.1, J2.2, JP2.1 (A), R1.2, R3.2, U1.3 (VOUT), U2.4 (VDD), U3.2 (~RE), U3.3 (DE), U3.8 (VCC)
3.3VA: C1.2, C2.2, C5.2, R1.1, U4.1 (VCC)
24V_HOST: C3.2, CN1.4, CN2.6, U1.2 (VIN)
BUF_A: CN2.1, D1.2 (A1), R2.2, U3.6 (A)
BUF_B: CN2.3, D1.1 (A1), R2.1, U3.7 (B)
BUF_PWM: JP1.2 (C), U3.4 (DI)
BUS_A: CN2.2, R5.2, R7.2
BUS_B: CN2.5, R6.2, R8.2
FILAMENT_OL_KEY: J2.1, R3.1, R4.2, SW1.1, U2.5 (PC1)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, CN1.2, CN2.4, D1.3 (K), J1.2, J2.3, LED1.3 (GND), R4.1, SW1.2, U1.1 (GND), U2.2 (VSS), U3.5 (GND), U4.3 (GND)
HALL_OUT: U2.3 (PA2), U4.2 (OUT)
unnamed: CN1.1, R7.1, R8.1
unnamed: CN1.3, R5.1, R6.1
unnamed: JP2.2 (B), LED1.1 (VDD)
PA1: JP1.3 (B), U2.1 (PD6/PA1)
PC4: JP1.1 (A), U2.7 (PC4)
SWIO: J1.3, U2.8 (PD1/PD4/PD5)
SYS_RGB: LED1.4 (DIN), U2.6 (PC2)

Notes on the sheet:
烧录和调试接口
耗材断料检测
霍尔传感器
MX3.0接口
CH32V203F6P6
串口-RS485
24V-3.3V电源

Board: 2 copper layers, 54.0 x 20.5 mm, 33 parts (0 on the bottom side), 18 nets.

## Code that names these connections

File src/main.c:

// Could be defined here, or in the processor defines.
#define SYSTEM_CORE_CLOCK 48000000
#define USE_CALC 1

#include "ch32v00x.h"
#if USE_CALC
#include "calibration.h"
#endif

#define APB_CLOCK SYSTEM_CORE_CLOCK
#define ADC_MAX 1023u
#define ADC_MIN_DEFAULT 0
#define ADC_MAX_DEFAULT 1023u
#define UART_ENABLE 0
#define BUTTON_DEBOUNCE_MS 20u
#define BUTTON_LONG_MS 1000u
#define PWM_USE_PC4 1 // 1 = TIM1 CH4 on PC4 (hardware PWM). 0 = TIM2 ISR on PA1.
#define PWM_DUTY_MIN_PERCENT 15u // Clamp output duty lower bound (0..100).
#define PWM_DUTY_MAX_PERCENT 90u // Clamp output duty upper bound (0..100).
#define WDT_ENABLE 0
#define WDT_PRESCALER IWDG_Prescaler_64
#define WDT_RELOAD 625u // ~1s at LSI ~40kHz: 40k/64 = 625Hz.
#define ADC_DMA_SAMPLES 16u

static volatile uint16_t adc_dma_buf[ADC_DMA_SAMPLES];

#if PWM_USE_PC4
static void SetupPWM_PC4_10k(void)
{
	// Enable GPIOC + AFIO + TIM1 clocks.
	RCC->APB2PCENR |= RCC_IOPCEN | RCC_AFIOEN | RCC_TIM1EN;

	// Reset TIM1 to a known state.
	RCC->APB2PRSTR |= RCC_TIM1RST;
	RCC->APB2PRSTR &= ~RCC_TIM1RST;

	// PC4 as AF push-pull, 50MHz.
	GPIOC->CFGLR &= ~(0xF << (4 * 4));
	GPIOC->CFGLR |= (GPIO_Speed_50MHz | GPIO_CNF_OUT_PP_AF) << (4 * 4);

	// TIM1 base: 48MHz / (PSC+1) / (ARR+1) = 10kHz
	TIM1->CTLR1 = 0;
	TIM1->CTLR2 = 0;
	TIM1->SMCFGR = 0;
	TIM1->PSC = 47;     // 48MHz / 48 = 1MHz
	TIM1->ATRLR = 99;   // 1MHz / 100 = 10kHz
	TIM1->CH4CVR = 50;  // start at 50% duty

	// PWM mode 1 on CH4, preload enable.
	TIM1->CHCTLR2 &= ~TIM_OC4M;
	TIM1->CHCTLR2 |= TIM_OC4PE | TIM_OC4M_1 | TIM_OC4M_2;
	TIM1->CCER |= TIM_CC4E;

	// Enable main output and start.
	TIM1->BDTR |= TIM_MOE;
	TIM1->SWEVGR = TIM_UG;
	TIM1->CTLR1 |= TIM_ARPE | TIM_CEN;
}

#else
static void SetupPWM_PA1_10k(void)
{
	// Enable GPIOA + TIM2 clocks.
	RCC->APB2PCENR |= RCC_IOPAEN;
	RCC->APB1PCENR |= RCC_TIM2EN;

	// Reset TIM2 to a known state.
	RCC->APB1PRSTR |= RCC_TIM2RST;
	RCC->APB1PRSTR &= ~RCC_TIM2RST;

	// PA1 as GPIO output (toggled in the ISR).
	GPIOA->CFGLR &= ~(0xF << (4 * 1));
	GPIOA->CFGLR |= (GPIO_Speed_50MHz | GPIO_CNF_OUT_PP) << (4 * 1);
	GPIOA->BCR = 1 << 1;

	// TIM2 base: 48MHz / (PSC+1) / (ARR+1) = 10kHz
	TIM2->CTLR1 = 0;
	TIM2->CTLR2 = 0;
	TIM2->SMCFGR = 0;
	TIM2->CHCTLR1 &= ~TIM_CC1S; // CC1 as output compare
	TIM2->PSC = 47;     // 48MHz / 48 = 1MHz
	TIM2->ATRLR = 99;   // 1MHz / 100 = 10kHz
	TIM2->CH1CVR = 50;  // start at 50% duty

	// Enable update + CC1 interrupts.
	TIM2->DMAINTENR |= TIM_UIE | TIM_CC1IE;
	NVIC_EnableIRQ(TIM2_IRQn);

	// Load registers and start.
	TIM2->SWEVGR = TIM_UG;
	TIM2->CTLR1 |= TIM_ARPE | TIM_CEN;
	__enable_irq();
}

void TIM2_IRQHandler(void) __attribute__((interrupt("WCH-Interrupt-fast")));
void TIM2_IRQHandler(void)
{
	uint16_t status = TIM2->INTFR;

	if (status & TIM_UIF)
	{
		TIM2->INTFR &= ~TIM_UIF;
		GPIOA->BSHR = 1 << 1;
	}
	if (status & TIM_CC1IF)
	{
		TIM2->INTFR &= ~TIM_CC1IF;
		GPIOA->BCR = 1 << 1;
	}
}
#endif

static void SetupADC_DMA_PA2(void)
{
	RCC->APB2PCENR |= RCC_IOPAEN | RCC_ADC1EN;
	RCC->AHBPCENR  |= RCC_DMA1EN;

	// ADC clock: 48MHz / 4 = 12MHz (max 14MHz)
	RCC->CFGR0 &= ~RCC_ADCPRE;
	RCC->CFGR0 |= RCC_ADCPRE_DIV4;

	// PA2 as analog input.
	GPIOA->CFGLR &= ~(0xF << (4 * 2));
	GPIOA->CFGLR |= (GPIO_CNF_IN_ANALOG | GPIO_SPEED_IN) << (4 * 2);

	// DMA1 Channel1: ADC1->RDATAR -> adc_dma_buf, circular, 16-bit.
	DMA1_Channel1->CFGR  = 0;
	DMA1_Channel1->CNTR  = ADC_DMA_SAMPLES;
	DMA1_Channel1->PADDR = (uint32_t)&ADC1->RDATAR;
	DMA1_Channel1->MADDR = (uint32_t)adc_dma_buf;
	DMA1_Channel1->CFGR  =
		DMA_CFGR1_MINC                    |  // increment memory address
		DMA_CFGR1_CIRC                    |  // circular: auto-reload CNTR
		DMA_CFGR1_PSIZE_0                 |  // peripheral 16-bit
		DMA_CFGR1_MSIZE_0                 |  // memory 16-bit
		DMA_CFGR1_PL_1 | DMA_CFGR1_PL_0  |  // very high priority
		DMA_CFGR1_EN;

	// Calibrate before enabling continuous+DMA.
	ADC1->CTLR1 = 0;
	ADC1->CTLR2 = ADC_ADON;
	ADC1->CTLR2 |= ADC_RSTCAL;
	while (ADC1->CTLR2 & ADC_RSTCAL) {}
	ADC1->CTLR2 |= ADC_CAL;
	while (ADC1->CTLR2 & ADC_CAL) {}

	// Continuous mode + DMA on channel 0, 241-cycle sample time.
	ADC1->CTLR2 &= ~ADC_EXTSEL;
	ADC1->CTLR2 |= ADC_ExternalTrigConv_None | ADC_EXTTRIG | ADC_DMA | ADC_CONT;
	ADC1->RSQR1  = 0;
	ADC1->RSQR2  = 0;
	ADC1->RSQR3  = ADC_Channel_0;
	ADC1->SAMPTR2 &= ~ADC_SMP0;
	ADC1->SAMPTR2 |= ADC_SampleTime_241Cycles;

	// Start — DMA fills buffer continuously from here.
	ADC1->CTLR2 |= ADC_SWSTART;
}

static void SetupInput_PC1_Pullup(void)
{
	RCC->APB2PCENR |= RCC_IOPCEN;

	// PC1 input with pull-up/down.
	GPIOC->CFGLR &= ~(0xF << (4 * 1));
	GPIOC->CFGLR |= (GPIO_SPEED_IN | GPIO_CNF_IN_PUPD) << (4 * 1);

	GPIOC->BSHR = 1 << 1; // pull-up (active low)
}

static uint16_t ReadADC_Average(void)
{
	uint32_t sum = 0;
	for (uint8_t i = 0; i < ADC_DMA_SAMPLES; i++)
		sum += adc_dma_buf[i];
	return (uint16_t)(sum / ADC_DMA_SAMPLES);
}

static uint8_t ButtonPressed(void)
{
	return (GPIOC->INDR & (1 << 1)) ? 0u : 1u;
}

#if WDT_ENABLE
static void SetupWDT(void)
{
	IWDG->CTLR = IWDG_WriteAccess_Enable;
	IWDG->PSCR = WDT_PRESCALER;
	IWDG->RLDR = (WDT_RELOAD & IWDG_RL);
	while (IWDG->STATR & (IWDG_PVU | IWDG_RVU)) {}
	IWDG->CTLR = CTLR_KEY_Reload;
	IWDG->CTLR = CTLR_KEY_Enable;
}

static inline void FeedWDT(void)
{
	IWDG->CTLR = CTLR_KEY_Reload;
}
#endif

int main()
{
	SystemInit48HSI();
#if UART_ENABLE
	SetupUART(UART_BRR);
	// printf("btn test\r\n");
#endif
	#if PWM_USE_PC4
	SetupPWM_PC4_10k();
	#else
	SetupPWM_PA1_10k();
	#endif
	#if USE_CALC
	SetupInput_PC1_Pullup();
	#endif
	SetupADC_DMA_PA2();
#if WDT_ENABLE
	SetupWDT();
#endif
	#if USE_CALC
	calib_data_t calib = { ADC_MIN_DEFAULT, ADC_MAX_DEFAULT };
	if (!calib_load(&calib) || calib.adc_max <= calib.adc_min)
	{
		calib.adc_min = ADC_MIN_DEFAULT;
		calib.adc_max = ADC_MAX_DEFAULT;
	}
	uint16_t press_ms = 0;
	uint8_t pressed_prev = 0;
	#endif
	
	while(1)
	{
		uint16_t adc_raw = ReadADC_Average();
		uint16_t adc = adc_raw;
		#if PWM_USE_PC4
		uint16_t arr = TIM1->ATRLR;
		#else
		uint16_t arr = TIM2->ATRLR;
		#endif
#if USE_CALC
		if (adc < calib.adc_min)
			adc = calib.adc_min;
		if (adc > calib.adc_max)
			adc = calib.adc_max;

		uint16_t span = (uint16_t)(calib.adc_max - calib.adc_min);
		uint16_t adj = (uint16_t)(adc - calib.adc_min);
#else
		if (adc < ADC_MIN_DEFAULT)
			adc = ADC_MIN_DEFAULT;
		if (adc > ADC_MAX_DEFAULT)
			adc = ADC_MAX_DEFAULT;

		uint16_t span = (uint16_t)(ADC_MAX_DEFAULT - ADC_MIN_DEFAULT);
		uint16_t adj = (uint16_t)(adc - ADC_MIN_DEFAULT);
#endif
		uint16_t ccr = (uint16_t)((adj * (uint32_t)(arr + 1)) / (span + 1));

		// Clamp mapped duty to user-defined min/max percentages.
		uint16_t ccr_min = (uint16_t)(((arr + 1u) * PWM_DUTY_MIN_PERCENT) / 100u);
		uint16_t ccr_max = (uint16_t)(((arr + 1u) * PWM_DUTY_MAX_PERCENT) / 100u);
		if (ccr_min == 0)
			ccr_min = 1;
		if (ccr_max >= arr)
			ccr_max = arr - 1;
		if (ccr_max <= ccr_min)
			ccr_max = (uint16_t)(ccr_min + 1u);

		if (ccr < ccr_min)
			ccr = ccr_min;
		if (ccr > ccr_max)
			ccr = ccr_max;

		#if PWM_USE_PC4
		TIM1->CH4CVR = ccr;
		#else
		TIM2->CH1CVR = ccr;
		#endif

#if USE_CALC
		uint8_t pressed = ButtonPressed();
		if (pressed)
		{
			if (press_ms < 60000u)
				press_ms = (uint16_t)(press_ms + 5u);
		}
		else if (pressed_prev)
		{
			if (press_ms >= BUTTON_LONG_MS)
			{
				calib.adc_max = adc_raw;
				if (calib.adc_max <= calib.adc_min)
					calib.adc_min = (calib.adc_max > 0) ? (uint16_t)(calib.adc_max - 1) : 0;
				calib_save(&calib);
				// printf("save max=%u\r\n", calib.adc_max);
			}
			else if (press_ms >= BUTTON_DEBOUNCE_MS)
			{
				calib.adc_min = adc_raw;
				if (calib.adc_min >= calib.adc_max)
					calib.adc_max = (uint16_t)(calib.adc_min + 1);
				calib_save(&calib);
				// printf("save min=%u\r\n", calib.adc_min);
			}
			press_ms = 0;
		}
		pressed_prev = pressed;
#endif

#if WDT_ENABLE
		FeedWDT();
#endif
		Delay_Ms(5);
	}
}

## Commit log

2026-02-14 change min max duty fix ams not detect buffer if pwm is lower
2026-02-14 added WDT
2026-05-14 fixed pwm frq not close 10Khz - improve adc dma
